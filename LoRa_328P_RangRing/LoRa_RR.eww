<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LoRa_STM8L_RangRing\LoRa_RR_STM8L.ewp</path>
    </project>
    <batchBuild />
</workspace>
