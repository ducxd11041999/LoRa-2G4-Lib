<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lib_Final.ewp</path>
    </project>
    <project>
        <path>D:\DuLieuKhoaLuan\TN_LoRa\LoRa_PingPong_Proj2\Project2.ewp</path>
    </project>
    <batchBuild />
</workspace>
